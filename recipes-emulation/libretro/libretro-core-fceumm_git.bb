SUMMARY = "Libretro port of FCE Ultra Modified Mappers"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://Copying;md5=6e233eda45c807aa29aeaa6d94bc48a2"

GITHUB_PROJECT = "libretro-fceumm"
LIBRETRO_CORE_NAME = "fceumm"

include libretro-core.inc

SRCREV = "e7e7610c27560fcf0d82ca258912bea15779b23e"
