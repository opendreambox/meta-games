SUMMARY = "Libretro port of hatari"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://readme.txt;beginline=26;endline=54;md5=d40eae85697ff0663ede4dd2d587d4ae"

GITHUB_PROJECT = "hatari"
LIBRETRO_CORE_NAME = "hatari"

include libretro-core.inc

SRCREV = "62bc27fd73e521fd9c8742a151ddca4b42b2aa25"
