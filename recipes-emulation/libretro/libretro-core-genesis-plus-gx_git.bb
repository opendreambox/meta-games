SUMMARY = "Libretro port of Genesis Plus GX"
LICENSE = "CLOSED"
LIC_FILES_CHKSUM = "file://LICENSE.txt;beginline=1;endline=38;md5=ab5c0e65dd24ef367040f7f6a17934db"

GITHUB_PROJECT = "Genesis-Plus-GX"
LIBRETRO_CORE_NAME = "genesis_plus_gx"

include libretro-core.inc

SRCREV = "f23676488eea5821e38f42eb143011d492f36df5"
