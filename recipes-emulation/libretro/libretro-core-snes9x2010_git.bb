SUMMARY = "Libretro port of Snes9X 2010"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://docs/gpl-2.0.txt;md5=751419260aa954499f7abaabaa882bbe"

GITHUB_PROJECT = "snes9x2010"
LIBRETRO_CORE_NAME = "snes9x2010"

include libretro-core.inc

SRCREV = "e3b7fa5544d2df0a91b3593b9a91b06df7ec83a4"
