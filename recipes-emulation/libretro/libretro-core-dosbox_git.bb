SUMMARY = "Libretro port of dosbox"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

GITHUB_PROJECT = "dosbox-libretro"
LIBRETRO_CORE_NAME = "dosbox"

include libretro-core.inc

SRCREV = "7216efe33153f028573ad68a843d897bdb11a69c"

