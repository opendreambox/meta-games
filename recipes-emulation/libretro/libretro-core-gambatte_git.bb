SUMMARY = "Libretro port of libgambatte"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

GITHUB_PROJECT = "gambatte-libretro"
LIBRETRO_CORE_NAME = "gambatte"

include libretro-core.inc

SRCREV = "ba2c2dc577cfb6a147922fdd1706d1ab82e942f8"
