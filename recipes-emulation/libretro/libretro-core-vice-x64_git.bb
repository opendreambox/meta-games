SUMMARY = "Libretro port of VBA Next"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README.MD;beginline=240;endline=253;md5=70690b5ebec9fc67c165fae15fa12c14"
DEPENDS = "flex-native"

GITHUB_PROJECT = "vice-libretro"
LIBRETRO_CORE_NAME = "vice_x64"

include libretro-core.inc

SRCREV = "ce4524df3c4e93e25dd97a6586c24c5e40d30c60"

