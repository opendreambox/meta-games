SUMMARY = "Libretro port of VBA Next"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://src/sound.cpp;beginline=1;endline=10;md5=d20eb22beb30e8239e91976af2e78bcb"

GITHUB_PROJECT = "vba-next"
LIBRETRO_CORE_NAME = "vba_next"

include libretro-core.inc

SRCREV = "15037175093511aab9a52e27f28989c6c6fdb674"
