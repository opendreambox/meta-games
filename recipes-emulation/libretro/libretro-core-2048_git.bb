SUMMARY = "Libretro port of the 2048 game"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=61287f92700ec1bdf13bc86d8228cd13"

GITHUB_PROJECT = "libretro-2048"
LIBRETRO_CORE_NAME = "2048"

include libretro-core.inc

SRCREV = "6e91356b9a901410017184a0d7772e40a92332a6"
